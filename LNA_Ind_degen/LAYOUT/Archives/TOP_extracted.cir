* Extracted by KLayout with SG13G2 LVS runset on : 06/06/2025 17:20

.SUBCKT TOP
M$1 \$2 \$7 \$3 \$1 sg13_lv_nmos L=0.13u W=10u AS=3.4p AD=3.4p PS=20.68u
+ PD=20.68u
R$2 \$1 \$3 ptap1 A=7.02p P=19.56u
.ENDS TOP
