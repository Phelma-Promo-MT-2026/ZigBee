* Qucs 25.1.2  /home/userproj/QucsWorkspace/Zigbee/LNA_Ind_degen/LNA_Inductance_degen_prj/LNA_single_miroir.sch
.INCLUDE "/usr/share/qucs-s/xspice_cmlib/include/ngspice_mathfunc.inc"

.SUBCKT IHP_PDK_nonlinear_components_sg13_lv_nmos  gnd d g s b w=0.35u l=0.34u ng=1 m=1 as=0 ad=0 pd=0 ps=0 trise=0 z1=0.346e-6 z2=0.38e-6 wmin=0.15e-6 rfmode=0 pre_layout=1 mlist=1
X1 d g s b  sg13_lv_nmos w={w} l={l} ng={ng} m={m} as={as} ad={ad} pd={pd}
+ ps={ps} trise={trise} z1={z1} z2={z2} wmin={wmin} rfmode={rfmode} pre_layout={pre_layout}
.ENDS

.SUBCKT Sub_SPfile_Ls 1 2
R1N 1 10 -50
R1P 10 11 100

A11 %vd(10 2) %vd(11, 2) xfer1
.model xfer1 xfer R_I=true table=[
+ 0Hz -0.93303 0
+ 5e+07Hz -0.932842 0.0193632
+ 1e+08Hz -0.932278 0.0387196
+ 1.5e+08Hz -0.931336 0.0580621
+ 2e+08Hz -0.930018 0.0773838
+ 2.5e+08Hz -0.928321 0.0966771
+ 3e+08Hz -0.926244 0.115935
+ 3.5e+08Hz -0.923785 0.135148
+ 4e+08Hz -0.920944 0.154309
+ 4.5e+08Hz -0.917719 0.173408
+ 5e+08Hz -0.914107 0.192436
+ 5.5e+08Hz -0.910107 0.211383
+ 6e+08Hz -0.905719 0.230237
+ 6.5e+08Hz -0.900941 0.248987
+ 7e+08Hz -0.895772 0.267621
+ 7.5e+08Hz -0.890212 0.286125
+ 8e+08Hz -0.884262 0.304486
+ 8.5e+08Hz -0.877924 0.32269
+ 9e+08Hz -0.8712 0.340722
+ 9.5e+08Hz -0.864093 0.358566
+ 1e+09Hz -0.856609 0.376206
+ 1.05e+09Hz -0.848752 0.393627
+ 1.1e+09Hz -0.840531 0.410812
+ 1.15e+09Hz -0.831954 0.427746
+ 1.2e+09Hz -0.823033 0.444411
+ 1.25e+09Hz -0.813778 0.460794
+ 1.3e+09Hz -0.804204 0.476879
+ 1.35e+09Hz -0.794325 0.492652
+ 1.4e+09Hz -0.784159 0.508102
+ 1.45e+09Hz -0.773724 0.523217
+ 1.5e+09Hz -0.763038 0.537988
+ 1.55e+09Hz -0.752123 0.552407
+ 1.6e+09Hz -0.740998 0.566468
+ 1.65e+09Hz -0.729685 0.580168
+ 1.7e+09Hz -0.718207 0.593507
+ 1.75e+09Hz -0.706583 0.606485
+ 1.8e+09Hz -0.694836 0.619105
+ 1.85e+09Hz -0.682984 0.631373
+ 1.9e+09Hz -0.671048 0.643298
+ 1.95e+09Hz -0.659044 0.654888
+ 2e+09Hz -0.646988 0.666155
+ 2.05e+09Hz -0.634894 0.677111
+ 2.1e+09Hz -0.622773 0.687769
+ 2.15e+09Hz -0.610634 0.698145
+ 2.2e+09Hz -0.598485 0.708253
+ 2.25e+09Hz -0.58633 0.718106
+ 2.3e+09Hz -0.574172 0.72772
+ 2.35e+09Hz -0.56201 0.737108
+ 2.4e+09Hz -0.549843 0.746281
+ 2.45e+09Hz -0.537667 0.755251
+ 2.5e+09Hz -0.525478 0.764028
+ 2.55e+09Hz -0.51327 0.772617
+ 2.6e+09Hz -0.501035 0.781026
+ 2.65e+09Hz -0.488767 0.789258
+ 2.7e+09Hz -0.476458 0.797313
+ 2.75e+09Hz -0.464101 0.805193
+ 2.8e+09Hz -0.451689 0.812895
+ 2.85e+09Hz -0.439216 0.820415
+ 2.9e+09Hz -0.426677 0.827747
+ 2.95e+09Hz -0.414069 0.834885
+ 3e+09Hz -0.401389 0.84182
+ 3.05e+09Hz -0.388637 0.848544
+ 3.1e+09Hz -0.375815 0.855047
+ 3.15e+09Hz -0.362926 0.86132
+ 3.2e+09Hz -0.349974 0.867354
+ 3.25e+09Hz -0.336968 0.873138
+ 3.3e+09Hz -0.323914 0.878665
+ 3.35e+09Hz -0.310824 0.883927
+ 3.4e+09Hz -0.297709 0.888918
+ 3.45e+09Hz -0.284582 0.893633
+ 3.5e+09Hz -0.271458 0.898068
+ 3.55e+09Hz -0.25835 0.902221
+ 3.6e+09Hz -0.245275 0.906095
+ 3.65e+09Hz -0.232246 0.90969
+ 3.7e+09Hz -0.21928 0.91301
+ 3.75e+09Hz -0.206391 0.916063
+ 3.8e+09Hz -0.193593 0.918856
+ 3.85e+09Hz -0.180899 0.921398
+ 3.9e+09Hz -0.168321 0.923701
+ 3.95e+09Hz -0.155869 0.925777
+ 4e+09Hz -0.143551 0.927641
+ 4.05e+09Hz -0.131374 0.929305
+ 4.1e+09Hz -0.119343 0.930785
+ 4.15e+09Hz -0.107461 0.932096
+ 4.2e+09Hz -0.0957278 0.933252
+ 4.25e+09Hz -0.0841439 0.934269
+ 4.3e+09Hz -0.0727061 0.93516
+ 4.35e+09Hz -0.0614101 0.935939
+ 4.4e+09Hz -0.0502501 0.936615
+ 4.45e+09Hz -0.0392192 0.937202
+ 4.5e+09Hz -0.0283094 0.937707
+ 4.55e+09Hz -0.0175118 0.938137
+ 4.6e+09Hz -0.00681721 0.9385
+ 4.65e+09Hz 0.00378392 0.938798
+ 4.7e+09Hz 0.0143011 0.939035
+ 4.75e+09Hz 0.0247437 0.939212
+ 4.8e+09Hz 0.0351204 0.939327
+ 4.85e+09Hz 0.0454393 0.939379
+ 4.9e+09Hz 0.0557077 0.939364
+ 4.95e+09Hz 0.0659316 0.939279
+ 5e+09Hz 0.0761161 0.939118
+ 5.05e+09Hz 0.0862649 0.938875
+ 5.1e+09Hz 0.0963802 0.938544
+ 5.15e+09Hz 0.106463 0.938119
+ 5.2e+09Hz 0.116513 0.937592
+ 5.25e+09Hz 0.126529 0.936958
+ 5.3e+09Hz 0.136507 0.936211
+ 5.35e+09Hz 0.146443 0.935344
+ 5.4e+09Hz 0.156332 0.934355
+ 5.45e+09Hz 0.166167 0.933238
+ 5.5e+09Hz 0.175943 0.931992
+ 5.55e+09Hz 0.185651 0.930614
+ 5.6e+09Hz 0.195284 0.929106
+ 5.65e+09Hz 0.204833 0.927466
+ 5.7e+09Hz 0.21429 0.925699
+ 5.75e+09Hz 0.223648 0.923806
+ 5.8e+09Hz 0.232899 0.921794
+ 5.85e+09Hz 0.242037 0.919667
+ 5.9e+09Hz 0.251054 0.917431
+ 5.95e+09Hz 0.259947 0.915096
+ 6e+09Hz 0.268711 0.912668
+ 6.05e+09Hz 0.277343 0.910157
+ 6.1e+09Hz 0.28584 0.907571
+ 6.15e+09Hz 0.294202 0.904919
+ 6.2e+09Hz 0.302429 0.902212
+ 6.25e+09Hz 0.310522 0.899458
+ 6.3e+09Hz 0.318485 0.896666
+ 6.35e+09Hz 0.326321 0.893843
+ 6.4e+09Hz 0.334035 0.890998
+ 6.45e+09Hz 0.341631 0.888137
+ 6.5e+09Hz 0.349117 0.885267
+ 6.55e+09Hz 0.356498 0.882391
+ 6.6e+09Hz 0.363781 0.879514
+ 6.65e+09Hz 0.370975 0.876639
+ 6.7e+09Hz 0.378086 0.873767
+ 6.75e+09Hz 0.385121 0.8709
+ 6.8e+09Hz 0.392087 0.868037
+ 6.85e+09Hz 0.398991 0.865176
+ 6.9e+09Hz 0.40584 0.862316
+ 6.95e+09Hz 0.412638 0.859454
+ 7e+09Hz 0.41939 0.856586
+ 7.05e+09Hz 0.426101 0.853709
+ 7.1e+09Hz 0.432773 0.850817
+ 7.15e+09Hz 0.439408 0.847906
+ 7.2e+09Hz 0.446009 0.844972
+ 7.25e+09Hz 0.452575 0.842009
+ 7.3e+09Hz 0.459106 0.839013
+ 7.35e+09Hz 0.465601 0.835979
+ 7.4e+09Hz 0.472057 0.832904
+ 7.45e+09Hz 0.478473 0.829783
+ 7.5e+09Hz 0.484844 0.826614
+ 7.55e+09Hz 0.491167 0.823394
+ 7.6e+09Hz 0.497438 0.820123
+ 7.65e+09Hz 0.503652 0.816798
+ 7.7e+09Hz 0.509804 0.81342
+ 7.75e+09Hz 0.515891 0.80999
+ 7.8e+09Hz 0.521907 0.806509
+ 7.85e+09Hz 0.527848 0.802979
+ 7.9e+09Hz 0.53371 0.799404
+ 7.95e+09Hz 0.53949 0.795787
+ 8e+09Hz 0.545184 0.792131
+ 8.05e+09Hz 0.550791 0.788443
+ 8.1e+09Hz 0.556308 0.784726
+ 8.15e+09Hz 0.561734 0.780986
+ 8.2e+09Hz 0.567069 0.777228
+ 8.25e+09Hz 0.572313 0.773457
+ 8.3e+09Hz 0.577467 0.76968
+ 8.35e+09Hz 0.582533 0.7659
+ 8.4e+09Hz 0.587514 0.762124
+ 8.45e+09Hz 0.592411 0.758354
+ 8.5e+09Hz 0.59723 0.754597
+ 8.55e+09Hz 0.601974 0.750854
+ 8.6e+09Hz 0.606646 0.747129
+ 8.65e+09Hz 0.611253 0.743424
+ 8.7e+09Hz 0.615798 0.739741
+ 8.75e+09Hz 0.620287 0.736081
+ 8.8e+09Hz 0.624724 0.732444
+ 8.85e+09Hz 0.629115 0.728829
+ 8.9e+09Hz 0.633463 0.725237
+ 8.95e+09Hz 0.637773 0.721665
+ 9e+09Hz 0.642049 0.718111
+ 9.05e+09Hz 0.646295 0.714573
+ 9.1e+09Hz 0.650512 0.711048
+ 9.15e+09Hz 0.654705 0.707532
+ 9.2e+09Hz 0.658874 0.704023
+ 9.25e+09Hz 0.663021 0.700517
+ 9.3e+09Hz 0.667147 0.69701
+ 9.35e+09Hz 0.671251 0.693499
+ 9.4e+09Hz 0.675333 0.68998
+ 9.45e+09Hz 0.679393 0.68645
+ 9.5e+09Hz 0.683428 0.682907
+ 9.55e+09Hz 0.687437 0.679347
+ 9.6e+09Hz 0.691417 0.675769
+ 9.65e+09Hz 0.695367 0.672171
+ 9.7e+09Hz 0.699282 0.668552
+ 9.75e+09Hz 0.70316 0.664911
+ 9.8e+09Hz 0.706998 0.661249
+ 9.85e+09Hz 0.710793 0.657564
+ 9.9e+09Hz 0.714543 0.653859
+ 9.95e+09Hz 0.718243 0.650134
+ 1e+10Hz 0.721891 0.646393
+ 1.005e+10Hz 0.725486 0.642635
+ 1.01e+10Hz 0.729026 0.638866
+ 1.015e+10Hz 0.732508 0.635087
+ 1.02e+10Hz 0.735931 0.631301
+ 1.025e+10Hz 0.739296 0.627512
+ 1.03e+10Hz 0.742602 0.623723
+ 1.035e+10Hz 0.745849 0.619938
+ 1.04e+10Hz 0.749038 0.61616
+ 1.045e+10Hz 0.752171 0.612392
+ 1.05e+10Hz 0.755249 0.608637
+ 1.055e+10Hz 0.758273 0.604899
+ 1.06e+10Hz 0.761248 0.601179
+ 1.065e+10Hz 0.764175 0.597479
+ 1.07e+10Hz 0.767058 0.593802
+ 1.075e+10Hz 0.769899 0.590149
+ 1.08e+10Hz 0.772702 0.58652
+ 1.085e+10Hz 0.77547 0.582917
+ 1.09e+10Hz 0.778208 0.579338
+ 1.095e+10Hz 0.780917 0.575783
+ 1.1e+10Hz 0.783601 0.572252
+ 1.105e+10Hz 0.786263 0.568744
+ 1.11e+10Hz 0.788906 0.565255
+ 1.115e+10Hz 0.791532 0.561786
+ 1.12e+10Hz 0.794142 0.558332
+ 1.125e+10Hz 0.79674 0.554893
+ 1.13e+10Hz 0.799325 0.551465
+ 1.135e+10Hz 0.801898 0.548045
+ 1.14e+10Hz 0.80446 0.544632
+ 1.145e+10Hz 0.807012 0.541222
+ 1.15e+10Hz 0.809552 0.537813
+ 1.155e+10Hz 0.812079 0.534402
+ 1.16e+10Hz 0.814593 0.530987
+ 1.165e+10Hz 0.817092 0.527566
+ 1.17e+10Hz 0.819574 0.524139
+ 1.175e+10Hz 0.822038 0.520702
+ 1.18e+10Hz 0.824481 0.517256
+ 1.185e+10Hz 0.826901 0.513799
+ 1.19e+10Hz 0.829296 0.510332
+ 1.195e+10Hz 0.831663 0.506855
+ 1.2e+10Hz 0.834 0.503368
+ 1.205e+10Hz 0.836305 0.499873
+ 1.21e+10Hz 0.838577 0.496369
+ 1.215e+10Hz 0.840813 0.49286
+ 1.22e+10Hz 0.843012 0.489346
+ 1.225e+10Hz 0.845172 0.485831
+ 1.23e+10Hz 0.847294 0.482315
+ 1.235e+10Hz 0.849376 0.478802
+ 1.24e+10Hz 0.851418 0.475294
+ 1.245e+10Hz 0.85342 0.471793
+ 1.25e+10Hz 0.855383 0.468301
+ 1.255e+10Hz 0.857308 0.464822
+ 1.26e+10Hz 0.859196 0.461357
+ 1.265e+10Hz 0.861049 0.457908
+ 1.27e+10Hz 0.862868 0.454477
+ 1.275e+10Hz 0.864655 0.451066
+ 1.28e+10Hz 0.866412 0.447675
+ 1.285e+10Hz 0.868143 0.444306
+ 1.29e+10Hz 0.869849 0.44096
+ 1.295e+10Hz 0.871532 0.437636
+ 1.3e+10Hz 0.873196 0.434334
+ 1.305e+10Hz 0.874843 0.431055
+ 1.31e+10Hz 0.876474 0.427797
+ 1.315e+10Hz 0.878093 0.424559
+ 1.32e+10Hz 0.879701 0.42134
+ 1.325e+10Hz 0.8813 0.418138
+ 1.33e+10Hz 0.882891 0.414952
+ 1.335e+10Hz 0.884477 0.411779
+ 1.34e+10Hz 0.886056 0.408619
+ 1.345e+10Hz 0.887631 0.405467
+ 1.35e+10Hz 0.889202 0.402323
+ 1.355e+10Hz 0.890768 0.399184
+ 1.36e+10Hz 0.892329 0.396048
+ 1.365e+10Hz 0.893884 0.392914
+ 1.37e+10Hz 0.895433 0.389778
+ 1.375e+10Hz 0.896974 0.386641
+ 1.38e+10Hz 0.898507 0.383499
+ 1.385e+10Hz 0.900028 0.380353
+ 1.39e+10Hz 0.901537 0.377201
+ 1.395e+10Hz 0.903031 0.374043
+ 1.4e+10Hz 0.90451 0.370879
+ 1.405e+10Hz 0.90597 0.367708
+ 1.41e+10Hz 0.907411 0.364531
+ 1.415e+10Hz 0.90883 0.361348
+ 1.42e+10Hz 0.910225 0.358161
+ 1.425e+10Hz 0.911596 0.354971
+ 1.43e+10Hz 0.91294 0.351778
+ 1.435e+10Hz 0.914258 0.348586
+ 1.44e+10Hz 0.915547 0.345394
+ 1.445e+10Hz 0.916808 0.342206
+ 1.45e+10Hz 0.91804 0.339023
+ 1.455e+10Hz 0.919243 0.335847
+ 1.46e+10Hz 0.920418 0.33268
+ 1.465e+10Hz 0.921565 0.329524
+ 1.47e+10Hz 0.922684 0.326381
+ 1.475e+10Hz 0.923779 0.323252
+ 1.48e+10Hz 0.924848 0.320139
+ 1.485e+10Hz 0.925895 0.317044
+ 1.49e+10Hz 0.926921 0.313967
+ 1.495e+10Hz 0.927927 0.310908
+ 1.5e+10Hz 0.928916 0.30787
+ 1.505e+10Hz 0.92989 0.304851
+ 1.51e+10Hz 0.930851 0.301852
+ 1.515e+10Hz 0.931801 0.298873
+ 1.52e+10Hz 0.932741 0.295912
+ 1.525e+10Hz 0.933674 0.29297
+ 1.53e+10Hz 0.934601 0.290044
+ 1.535e+10Hz 0.935525 0.287135
+ 1.54e+10Hz 0.936445 0.284239
+ 1.545e+10Hz 0.937363 0.281356
+ 1.55e+10Hz 0.93828 0.278484
+ 1.555e+10Hz 0.939197 0.27562
+ 1.56e+10Hz 0.940113 0.272764
+ 1.565e+10Hz 0.941029 0.269913
+ 1.57e+10Hz 0.941945 0.267065
+ 1.575e+10Hz 0.942859 0.264219
+ 1.58e+10Hz 0.943772 0.261373
+ 1.585e+10Hz 0.944681 0.258525
+ 1.59e+10Hz 0.945586 0.255675
+ 1.595e+10Hz 0.946486 0.25282
+ 1.6e+10Hz 0.947378 0.249961
+ 1.605e+10Hz 0.948262 0.247097
+ 1.61e+10Hz 0.949135 0.244227
+ 1.615e+10Hz 0.949996 0.241351
+ 1.62e+10Hz 0.950843 0.23847
+ 1.625e+10Hz 0.951675 0.235584
+ 1.63e+10Hz 0.952489 0.232693
+ 1.635e+10Hz 0.953285 0.2298
+ 1.64e+10Hz 0.954062 0.226904
+ 1.645e+10Hz 0.954817 0.224007
+ 1.65e+10Hz 0.95555 0.221112
+ 1.655e+10Hz 0.956262 0.218218
+ 1.66e+10Hz 0.95695 0.215329
+ 1.665e+10Hz 0.957616 0.212446
+ 1.67e+10Hz 0.958259 0.20957
+ 1.675e+10Hz 0.95888 0.206704
+ 1.68e+10Hz 0.959479 0.203848
+ 1.685e+10Hz 0.960058 0.201006
+ 1.69e+10Hz 0.960617 0.198177
+ 1.695e+10Hz 0.961158 0.195364
+ 1.7e+10Hz 0.961683 0.192567
+ 1.705e+10Hz 0.962193 0.189787
+ 1.71e+10Hz 0.962689 0.187025
+ 1.715e+10Hz 0.963174 0.184281
+ 1.72e+10Hz 0.96365 0.181554
+ 1.725e+10Hz 0.964118 0.178846
+ 1.73e+10Hz 0.96458 0.176155
+ 1.735e+10Hz 0.965038 0.173481
+ 1.74e+10Hz 0.965494 0.170823
+ 1.745e+10Hz 0.965948 0.168179
+ 1.75e+10Hz 0.966403 0.165548
+ 1.755e+10Hz 0.966859 0.162929
+ 1.76e+10Hz 0.967317 0.16032
+ 1.765e+10Hz 0.967777 0.157719
+ 1.77e+10Hz 0.96824 0.155125
+ 1.775e+10Hz 0.968706 0.152536
+ 1.78e+10Hz 0.969175 0.149949
+ 1.785e+10Hz 0.969645 0.147364
+ 1.79e+10Hz 0.970118 0.144779
+ 1.795e+10Hz 0.970591 0.142191
+ 1.8e+10Hz 0.971063 0.139601
+ 1.805e+10Hz 0.971533 0.137006
+ 1.81e+10Hz 0.972 0.134407
+ 1.815e+10Hz 0.972462 0.131801
+ 1.82e+10Hz 0.972917 0.129189
+ 1.825e+10Hz 0.973363 0.126571
+ 1.83e+10Hz 0.9738 0.123947
+ 1.835e+10Hz 0.974225 0.121316
+ 1.84e+10Hz 0.974636 0.11868
+ 1.845e+10Hz 0.975032 0.11604
+ 1.85e+10Hz 0.975412 0.113397
+ 1.855e+10Hz 0.975775 0.110751
+ 1.86e+10Hz 0.97612 0.108105
+ 1.865e+10Hz 0.976445 0.10546
+ 1.87e+10Hz 0.97675 0.102817
+ 1.875e+10Hz 0.977036 0.100179
+ 1.88e+10Hz 0.977302 0.0975469
+ 1.885e+10Hz 0.977548 0.0949228
+ 1.89e+10Hz 0.977775 0.0923083
+ 1.895e+10Hz 0.977984 0.0897051
+ 1.9e+10Hz 0.978176 0.0871146
+ 1.905e+10Hz 0.978352 0.0845382
+ 1.91e+10Hz 0.978514 0.0819771
+ 1.915e+10Hz 0.978662 0.0794321
+ 1.92e+10Hz 0.9788 0.076904
+ 1.925e+10Hz 0.978928 0.0743931
+ 1.93e+10Hz 0.979049 0.0718997
+ 1.935e+10Hz 0.979164 0.0694237
+ 1.94e+10Hz 0.979275 0.0669646
+ 1.945e+10Hz 0.979384 0.0645219
+ 1.95e+10Hz 0.979493 0.0620947
+ 1.955e+10Hz 0.979603 0.0596819
+ 1.96e+10Hz 0.979716 0.0572821
+ 1.965e+10Hz 0.979832 0.0548939
+ 1.97e+10Hz 0.979953 0.0525156
+ 1.975e+10Hz 0.98008 0.0501455
+ 1.98e+10Hz 0.980212 0.0477816
+ 1.985e+10Hz 0.980349 0.0454222
+ 1.99e+10Hz 0.980493 0.0430653
+ 1.995e+10Hz 0.980642 0.0407091
+ 2e+10Hz 0.980795 0.0383519
+ 2.005e+10Hz 0.980952 0.035992
+ 2.01e+10Hz 0.981112 0.033628
+ 2.015e+10Hz 0.981273 0.0312585
+ 2.02e+10Hz 0.981433 0.0288826
+ 2.025e+10Hz 0.981591 0.0264993
+ 2.03e+10Hz 0.981746 0.0241082
+ 2.035e+10Hz 0.981895 0.0217089
+ 2.04e+10Hz 0.982036 0.0193013
+ 2.045e+10Hz 0.982167 0.0168859
+ 2.05e+10Hz 0.982288 0.0144631
+ 2.055e+10Hz 0.982395 0.0120338
+ 2.06e+10Hz 0.982488 0.00959905
+ 2.065e+10Hz 0.982565 0.00716012
+ 2.07e+10Hz 0.982625 0.00471853
+ 2.075e+10Hz 0.982667 0.00227597
+ 2.08e+10Hz 0.98269 -0.00016575
+ 2.085e+10Hz 0.982694 -0.00260474
+ 2.09e+10Hz 0.982678 -0.00503902
+ 2.095e+10Hz 0.982644 -0.00746665
+ 2.1e+10Hz 0.98259 -0.00988567
+ 2.105e+10Hz 0.982519 -0.0122942
+ 2.11e+10Hz 0.982431 -0.0146906
+ 2.115e+10Hz 0.982327 -0.0170732
+ 2.12e+10Hz 0.982208 -0.0194406
+ 2.125e+10Hz 0.982077 -0.0217916
+ 2.13e+10Hz 0.981936 -0.0241255
+ 2.135e+10Hz 0.981785 -0.0264414
+ 2.14e+10Hz 0.981628 -0.0287391
+ 2.145e+10Hz 0.981467 -0.0310185
+ 2.15e+10Hz 0.981303 -0.0332799
+ 2.155e+10Hz 0.981138 -0.0355239
+ 2.16e+10Hz 0.980975 -0.0377513
+ 2.165e+10Hz 0.980816 -0.0399632
+ 2.17e+10Hz 0.980661 -0.0421611
+ 2.175e+10Hz 0.980512 -0.0443465
+ 2.18e+10Hz 0.980371 -0.0465212
+ 2.185e+10Hz 0.980239 -0.0486873
+ 2.19e+10Hz 0.980115 -0.0508468
+ 2.195e+10Hz 0.980001 -0.0530019
+ 2.2e+10Hz 0.979896 -0.0551546
+ 2.205e+10Hz 0.9798 -0.0573073
+ 2.21e+10Hz 0.979712 -0.059462
+ 2.215e+10Hz 0.979631 -0.0616205
+ 2.22e+10Hz 0.979557 -0.0637849
+ 2.225e+10Hz 0.979487 -0.0659566
+ 2.23e+10Hz 0.979419 -0.0681371
+ 2.235e+10Hz 0.979353 -0.0703275
+ 2.24e+10Hz 0.979286 -0.0725285
+ 2.245e+10Hz 0.979215 -0.0747407
+ 2.25e+10Hz 0.979138 -0.0769643
+ 2.255e+10Hz 0.979054 -0.0791991
+ 2.26e+10Hz 0.978959 -0.0814446
+ 2.265e+10Hz 0.978852 -0.0837
+ 2.27e+10Hz 0.978731 -0.085964
+ 2.275e+10Hz 0.978594 -0.0882354
+ 2.28e+10Hz 0.97844 -0.0905124
+ 2.285e+10Hz 0.978266 -0.092793
+ 2.29e+10Hz 0.978073 -0.0950751
+ 2.295e+10Hz 0.977858 -0.0973565
+ 2.3e+10Hz 0.977623 -0.0996348
+ 2.305e+10Hz 0.977367 -0.101908
+ 2.31e+10Hz 0.97709 -0.104173
+ 2.315e+10Hz 0.976793 -0.106427
+ 2.32e+10Hz 0.976477 -0.10867
+ 2.325e+10Hz 0.976144 -0.110897
+ 2.33e+10Hz 0.975794 -0.113109
+ 2.335e+10Hz 0.975431 -0.115302
+ 2.34e+10Hz 0.975056 -0.117476
+ 2.345e+10Hz 0.974672 -0.11963
+ 2.35e+10Hz 0.97428 -0.121764
+ 2.355e+10Hz 0.973884 -0.123876
+ 2.36e+10Hz 0.973487 -0.125967
+ 2.365e+10Hz 0.97309 -0.128037
+ 2.37e+10Hz 0.972697 -0.130088
+ 2.375e+10Hz 0.972309 -0.132121
+ 2.38e+10Hz 0.971929 -0.134136
+ 2.385e+10Hz 0.971558 -0.136137
+ 2.39e+10Hz 0.971199 -0.138125
+ 2.395e+10Hz 0.970853 -0.140103
+ 2.4e+10Hz 0.97052 -0.142073
+ 2.405e+10Hz 0.970201 -0.144038
+ 2.41e+10Hz 0.969897 -0.146
+ 2.415e+10Hz 0.969607 -0.147963
+ 2.42e+10Hz 0.96933 -0.149929
+ 2.425e+10Hz 0.969065 -0.151901
+ 2.43e+10Hz 0.968811 -0.153881
+ 2.435e+10Hz 0.968567 -0.155872
+ 2.44e+10Hz 0.968329 -0.157875
+ 2.445e+10Hz 0.968097 -0.159891
+ 2.45e+10Hz 0.967866 -0.161924
+ 2.455e+10Hz 0.967634 -0.163972
+ 2.46e+10Hz 0.967399 -0.166037
+ 2.465e+10Hz 0.967157 -0.168118
+ 2.47e+10Hz 0.966906 -0.170216
+ 2.475e+10Hz 0.966642 -0.172329
+ 2.48e+10Hz 0.966362 -0.174456
+ 2.485e+10Hz 0.966065 -0.176595
+ 2.49e+10Hz 0.965748 -0.178745
+ 2.495e+10Hz 0.965409 -0.180902
+ 2.5e+10Hz 0.965046 -0.183065
+ 2.505e+10Hz 0.964658 -0.18523
+ 2.51e+10Hz 0.964245 -0.187394
+ 2.515e+10Hz 0.963806 -0.189554
+ 2.52e+10Hz 0.963341 -0.191706
+ 2.525e+10Hz 0.962851 -0.193848
+ 2.53e+10Hz 0.962338 -0.195976
+ 2.535e+10Hz 0.961801 -0.198088
+ 2.54e+10Hz 0.961245 -0.200181
+ 2.545e+10Hz 0.960671 -0.202251
+ 2.55e+10Hz 0.960082 -0.204299
+ 2.555e+10Hz 0.959481 -0.206321
+ 2.56e+10Hz 0.958871 -0.208316
+ 2.565e+10Hz 0.958256 -0.210285
+ 2.57e+10Hz 0.957639 -0.212227
+ 2.575e+10Hz 0.957025 -0.214141
+ 2.58e+10Hz 0.956415 -0.21603
+ 2.585e+10Hz 0.955814 -0.217895
+ 2.59e+10Hz 0.955225 -0.219737
+ 2.595e+10Hz 0.954651 -0.22156
+ 2.6e+10Hz 0.954094 -0.223364
+ 2.605e+10Hz 0.953556 -0.225155
+ 2.61e+10Hz 0.953039 -0.226935
+ 2.615e+10Hz 0.952544 -0.228708
+ 2.62e+10Hz 0.952071 -0.230478
+ 2.625e+10Hz 0.951621 -0.232249
+ 2.63e+10Hz 0.951192 -0.234024
+ 2.635e+10Hz 0.950784 -0.235808
+ 2.64e+10Hz 0.950395 -0.237603
+ 2.645e+10Hz 0.950023 -0.239414
+ 2.65e+10Hz 0.949664 -0.241243
+ 2.655e+10Hz 0.949316 -0.243093
+ 2.66e+10Hz 0.948975 -0.244967
+ 2.665e+10Hz 0.948637 -0.246864
+ 2.67e+10Hz 0.948298 -0.248788
+ 2.675e+10Hz 0.947954 -0.250737
+ 2.68e+10Hz 0.9476 -0.252712
+ 2.685e+10Hz 0.947233 -0.254711
+ 2.69e+10Hz 0.946848 -0.256734
+ 2.695e+10Hz 0.946441 -0.258779
+ 2.7e+10Hz 0.946008 -0.260841
+ 2.705e+10Hz 0.945547 -0.262919
+ 2.71e+10Hz 0.945055 -0.265008
+ 2.715e+10Hz 0.94453 -0.267104
+ 2.72e+10Hz 0.94397 -0.269203
+ 2.725e+10Hz 0.943374 -0.271301
+ 2.73e+10Hz 0.942742 -0.273391
+ 2.735e+10Hz 0.942075 -0.275471
+ 2.74e+10Hz 0.941374 -0.277534
+ 2.745e+10Hz 0.940642 -0.279577
+ 2.75e+10Hz 0.93988 -0.281594
+ 2.755e+10Hz 0.939091 -0.283583
+ 2.76e+10Hz 0.938281 -0.285541
+ 2.765e+10Hz 0.937453 -0.287463
+ 2.77e+10Hz 0.936613 -0.289348
+ 2.775e+10Hz 0.935764 -0.291196
+ 2.78e+10Hz 0.934912 -0.293004
+ 2.785e+10Hz 0.934063 -0.294774
+ 2.79e+10Hz 0.933223 -0.296505
+ 2.795e+10Hz 0.932395 -0.298201
+ 2.8e+10Hz 0.931586 -0.299863
+ 2.805e+10Hz 0.930799 -0.301495
+ 2.81e+10Hz 0.93004 -0.3031
+ 2.815e+10Hz 0.929311 -0.304683
+ 2.82e+10Hz 0.928615 -0.30625
+ 2.825e+10Hz 0.927954 -0.307805
+ 2.83e+10Hz 0.927331 -0.309354
+ 2.835e+10Hz 0.926744 -0.310903
+ 2.84e+10Hz 0.926194 -0.312459
+ 2.845e+10Hz 0.92568 -0.314027
+ 2.85e+10Hz 0.925198 -0.315613
+ 2.855e+10Hz 0.924747 -0.317223
+ 2.86e+10Hz 0.924322 -0.318861
+ 2.865e+10Hz 0.923919 -0.320532
+ 2.87e+10Hz 0.923532 -0.32224
+ 2.875e+10Hz 0.923155 -0.323987
+ 2.88e+10Hz 0.922783 -0.325776
+ 2.885e+10Hz 0.922409 -0.327609
+ 2.89e+10Hz 0.922025 -0.329484
+ 2.895e+10Hz 0.921625 -0.331402
+ 2.9e+10Hz 0.921202 -0.33336
+ 2.905e+10Hz 0.92075 -0.335356
+ 2.91e+10Hz 0.920262 -0.337386
+ 2.915e+10Hz 0.919734 -0.339445
+ 2.92e+10Hz 0.91916 -0.341528
+ 2.925e+10Hz 0.918536 -0.343627
+ 2.93e+10Hz 0.91786 -0.345737
+ 2.935e+10Hz 0.917129 -0.34785
+ 2.94e+10Hz 0.916343 -0.349958
+ 2.945e+10Hz 0.915501 -0.352054
+ 2.95e+10Hz 0.914606 -0.35413
+ 2.955e+10Hz 0.913659 -0.356177
+ 2.96e+10Hz 0.912664 -0.358189
+ 2.965e+10Hz 0.911627 -0.36016
+ 2.97e+10Hz 0.910553 -0.362082
+ 2.975e+10Hz 0.909448 -0.363952
+ 2.98e+10Hz 0.908321 -0.365765
+ 2.985e+10Hz 0.907179 -0.367518
+ 2.99e+10Hz 0.90603 -0.369208
+ 2.995e+10Hz 0.904885 -0.370837
+ 3e+10Hz 0.903751 -0.372404
+ ]

.ENDS
.SUBCKT Sub_SPfile_LL 1 2
R1N 1 10 -50
R1P 10 11 100

A11 %vd(10 2) %vd(11, 2) xfer1
.model xfer1 xfer R_I=true table=[
+ 0Hz -0.894201 0
+ 7.5e+07Hz -0.892952 0.048473
+ 1.5e+08Hz -0.889213 0.0967726
+ 2.25e+08Hz -0.883006 0.144727
+ 3e+08Hz -0.874368 0.192166
+ 3.75e+08Hz -0.86335 0.238926
+ 4.5e+08Hz -0.850016 0.284846
+ 5.25e+08Hz -0.834444 0.329775
+ 6e+08Hz -0.816724 0.373567
+ 6.75e+08Hz -0.796957 0.416086
+ 7.5e+08Hz -0.775257 0.457209
+ 8.25e+08Hz -0.751744 0.49682
+ 9e+08Hz -0.726548 0.534818
+ 9.75e+08Hz -0.699806 0.571113
+ 1.05e+09Hz -0.67166 0.605629
+ 1.125e+09Hz -0.642256 0.638304
+ 1.2e+09Hz -0.611745 0.669089
+ 1.275e+09Hz -0.580276 0.69795
+ 1.35e+09Hz -0.548 0.724866
+ 1.425e+09Hz -0.515065 0.749831
+ 1.5e+09Hz -0.481618 0.772851
+ 1.575e+09Hz -0.447799 0.793944
+ 1.65e+09Hz -0.413745 0.813144
+ 1.725e+09Hz -0.379584 0.830491
+ 1.8e+09Hz -0.345436 0.846038
+ 1.875e+09Hz -0.311415 0.859847
+ 1.95e+09Hz -0.277622 0.871986
+ 2.025e+09Hz -0.244151 0.882531
+ 2.1e+09Hz -0.211083 0.891563
+ 2.175e+09Hz -0.17849 0.899165
+ 2.25e+09Hz -0.146433 0.905425
+ 2.325e+09Hz -0.114962 0.910431
+ 2.4e+09Hz -0.0841168 0.91427
+ 2.475e+09Hz -0.0539279 0.917028
+ 2.55e+09Hz -0.0244165 0.91879
+ 2.625e+09Hz 0.0044046 0.919636
+ 2.7e+09Hz 0.0325301 0.919642
+ 2.775e+09Hz 0.0599613 0.918882
+ 2.85e+09Hz 0.0867053 0.91742
+ 2.925e+09Hz 0.112774 0.915319
+ 3e+09Hz 0.138182 0.912634
+ 3.075e+09Hz 0.162949 0.909413
+ 3.15e+09Hz 0.187094 0.905701
+ 3.225e+09Hz 0.210638 0.901535
+ 3.3e+09Hz 0.233603 0.89695
+ 3.375e+09Hz 0.25601 0.891973
+ 3.45e+09Hz 0.277879 0.886629
+ 3.525e+09Hz 0.299229 0.880937
+ 3.6e+09Hz 0.320076 0.874915
+ 3.675e+09Hz 0.340436 0.868577
+ 3.75e+09Hz 0.360322 0.861936
+ 3.825e+09Hz 0.379743 0.855003
+ 3.9e+09Hz 0.39871 0.847787
+ 3.975e+09Hz 0.417228 0.840298
+ 4.05e+09Hz 0.435302 0.832546
+ 4.125e+09Hz 0.452935 0.824539
+ 4.2e+09Hz 0.47013 0.816288
+ 4.275e+09Hz 0.486886 0.807804
+ 4.35e+09Hz 0.503205 0.799099
+ 4.425e+09Hz 0.519086 0.790184
+ 4.5e+09Hz 0.534529 0.781075
+ 4.575e+09Hz 0.549533 0.771786
+ 4.65e+09Hz 0.564101 0.762332
+ 4.725e+09Hz 0.578232 0.75273
+ 4.8e+09Hz 0.591929 0.742996
+ 4.875e+09Hz 0.605196 0.73315
+ 4.95e+09Hz 0.618038 0.723207
+ 5.025e+09Hz 0.63046 0.713186
+ 5.1e+09Hz 0.64247 0.703104
+ 5.175e+09Hz 0.654076 0.692978
+ 5.25e+09Hz 0.66529 0.682825
+ 5.325e+09Hz 0.676122 0.672658
+ 5.4e+09Hz 0.686585 0.662494
+ 5.475e+09Hz 0.696692 0.652343
+ 5.55e+09Hz 0.706456 0.642219
+ 5.625e+09Hz 0.715894 0.63213
+ 5.7e+09Hz 0.72502 0.622086
+ 5.775e+09Hz 0.733849 0.612092
+ 5.85e+09Hz 0.742396 0.602156
+ 5.925e+09Hz 0.750677 0.592279
+ 6e+09Hz 0.758705 0.582465
+ 6.075e+09Hz 0.766494 0.572715
+ 6.15e+09Hz 0.774059 0.563028
+ 6.225e+09Hz 0.78141 0.553403
+ 6.3e+09Hz 0.788559 0.543838
+ 6.375e+09Hz 0.795516 0.534328
+ 6.45e+09Hz 0.802289 0.524872
+ 6.525e+09Hz 0.808888 0.515464
+ 6.6e+09Hz 0.815317 0.506101
+ 6.675e+09Hz 0.821584 0.496778
+ 6.75e+09Hz 0.827691 0.48749
+ 6.825e+09Hz 0.833642 0.478234
+ 6.9e+09Hz 0.83944 0.469006
+ 6.975e+09Hz 0.845086 0.459802
+ 7.05e+09Hz 0.850581 0.45062
+ 7.125e+09Hz 0.855925 0.441458
+ 7.2e+09Hz 0.861119 0.432314
+ 7.275e+09Hz 0.866161 0.423188
+ 7.35e+09Hz 0.871052 0.41408
+ 7.425e+09Hz 0.87579 0.404991
+ 7.5e+09Hz 0.880376 0.395921
+ 7.575e+09Hz 0.884808 0.386873
+ 7.65e+09Hz 0.889087 0.37785
+ 7.725e+09Hz 0.893214 0.368854
+ 7.8e+09Hz 0.897188 0.359888
+ 7.875e+09Hz 0.901012 0.350957
+ 7.95e+09Hz 0.904686 0.342064
+ 8.025e+09Hz 0.908214 0.333212
+ 8.1e+09Hz 0.911598 0.324405
+ 8.175e+09Hz 0.914842 0.315647
+ 8.25e+09Hz 0.917949 0.306942
+ 8.325e+09Hz 0.920925 0.298291
+ 8.4e+09Hz 0.923772 0.289699
+ 8.475e+09Hz 0.926497 0.281167
+ 8.55e+09Hz 0.929105 0.272696
+ 8.625e+09Hz 0.931601 0.264288
+ 8.7e+09Hz 0.93399 0.255944
+ 8.775e+09Hz 0.936278 0.247664
+ 8.85e+09Hz 0.93847 0.239447
+ 8.925e+09Hz 0.940571 0.231292
+ 9e+09Hz 0.942586 0.223198
+ 9.075e+09Hz 0.94452 0.215163
+ 9.15e+09Hz 0.946376 0.207185
+ 9.225e+09Hz 0.948159 0.199261
+ 9.3e+09Hz 0.949872 0.191389
+ 9.375e+09Hz 0.951517 0.183565
+ 9.45e+09Hz 0.953097 0.175786
+ 9.525e+09Hz 0.954614 0.16805
+ 9.6e+09Hz 0.956068 0.160353
+ 9.675e+09Hz 0.957461 0.152692
+ 9.75e+09Hz 0.958794 0.145064
+ 9.825e+09Hz 0.960065 0.137467
+ 9.9e+09Hz 0.961275 0.129899
+ 9.975e+09Hz 0.962423 0.122358
+ 1.005e+10Hz 0.963508 0.114842
+ 1.0125e+10Hz 0.96453 0.107349
+ 1.02e+10Hz 0.965486 0.0998795
+ 1.0275e+10Hz 0.966377 0.0924326
+ 1.035e+10Hz 0.967199 0.0850081
+ 1.0425e+10Hz 0.967954 0.0776063
+ 1.05e+10Hz 0.968639 0.0702279
+ 1.0575e+10Hz 0.969253 0.0628737
+ 1.065e+10Hz 0.969797 0.0555449
+ 1.0725e+10Hz 0.97027 0.0482429
+ 1.08e+10Hz 0.970671 0.0409692
+ 1.0875e+10Hz 0.971002 0.0337254
+ 1.095e+10Hz 0.971261 0.0265133
+ 1.1025e+10Hz 0.971452 0.0193345
+ 1.11e+10Hz 0.971574 0.0121907
+ 1.1175e+10Hz 0.971628 0.00508336
+ 1.125e+10Hz 0.971618 -0.00198605
+ 1.1325e+10Hz 0.971544 -0.00901636
+ 1.14e+10Hz 0.971409 -0.0160066
+ 1.1475e+10Hz 0.971215 -0.022956
+ 1.155e+10Hz 0.970964 -0.0298641
+ 1.1625e+10Hz 0.970659 -0.0367307
+ 1.17e+10Hz 0.970302 -0.0435559
+ 1.1775e+10Hz 0.969896 -0.0503403
+ 1.185e+10Hz 0.969443 -0.0570843
+ 1.1925e+10Hz 0.968945 -0.063789
+ 1.2e+10Hz 0.968404 -0.0704555
+ 1.2075e+10Hz 0.967823 -0.0770853
+ 1.215e+10Hz 0.967202 -0.0836799
+ 1.2225e+10Hz 0.966543 -0.090241
+ 1.23e+10Hz 0.965848 -0.0967705
+ 1.2375e+10Hz 0.965116 -0.10327
+ 1.245e+10Hz 0.96435 -0.109742
+ 1.2525e+10Hz 0.963548 -0.116188
+ 1.26e+10Hz 0.962711 -0.122609
+ 1.2675e+10Hz 0.961839 -0.129009
+ 1.275e+10Hz 0.960931 -0.135387
+ 1.2825e+10Hz 0.959987 -0.141745
+ 1.29e+10Hz 0.959006 -0.148085
+ 1.2975e+10Hz 0.957986 -0.154408
+ 1.305e+10Hz 0.956928 -0.160714
+ 1.3125e+10Hz 0.955828 -0.167004
+ 1.32e+10Hz 0.954687 -0.173278
+ 1.3275e+10Hz 0.953504 -0.179536
+ 1.335e+10Hz 0.952276 -0.185778
+ 1.3425e+10Hz 0.951004 -0.192003
+ 1.35e+10Hz 0.949686 -0.198211
+ 1.3575e+10Hz 0.948321 -0.204401
+ 1.365e+10Hz 0.94691 -0.210572
+ 1.3725e+10Hz 0.945451 -0.216722
+ 1.38e+10Hz 0.943944 -0.222851
+ 1.3875e+10Hz 0.942389 -0.228957
+ 1.395e+10Hz 0.940788 -0.23504
+ 1.4025e+10Hz 0.939139 -0.241098
+ 1.41e+10Hz 0.937444 -0.247129
+ 1.4175e+10Hz 0.935704 -0.253133
+ 1.425e+10Hz 0.93392 -0.259109
+ 1.4325e+10Hz 0.932092 -0.265056
+ 1.44e+10Hz 0.930223 -0.270974
+ 1.4475e+10Hz 0.928313 -0.276861
+ 1.455e+10Hz 0.926364 -0.282718
+ 1.4625e+10Hz 0.924377 -0.288545
+ 1.47e+10Hz 0.922355 -0.294342
+ 1.4775e+10Hz 0.920297 -0.300109
+ 1.485e+10Hz 0.918206 -0.305847
+ 1.4925e+10Hz 0.916083 -0.311556
+ 1.5e+10Hz 0.91393 -0.317238
+ 1.5075e+10Hz 0.911746 -0.322893
+ 1.515e+10Hz 0.909532 -0.328523
+ 1.5225e+10Hz 0.907291 -0.334129
+ 1.53e+10Hz 0.905021 -0.339712
+ 1.5375e+10Hz 0.902722 -0.345273
+ 1.545e+10Hz 0.900396 -0.350814
+ 1.5525e+10Hz 0.898042 -0.356336
+ 1.56e+10Hz 0.895659 -0.361841
+ 1.5675e+10Hz 0.893247 -0.367328
+ 1.575e+10Hz 0.890805 -0.3728
+ 1.5825e+10Hz 0.888332 -0.378256
+ 1.59e+10Hz 0.885827 -0.383699
+ 1.5975e+10Hz 0.88329 -0.389127
+ 1.605e+10Hz 0.880718 -0.394541
+ 1.6125e+10Hz 0.878112 -0.399942
+ 1.62e+10Hz 0.87547 -0.405329
+ 1.6275e+10Hz 0.87279 -0.410702
+ 1.635e+10Hz 0.870072 -0.416061
+ 1.6425e+10Hz 0.867315 -0.421404
+ 1.65e+10Hz 0.864518 -0.426731
+ 1.6575e+10Hz 0.861681 -0.432041
+ 1.665e+10Hz 0.858802 -0.437333
+ 1.6725e+10Hz 0.855883 -0.442606
+ 1.68e+10Hz 0.852921 -0.447858
+ 1.6875e+10Hz 0.849918 -0.453089
+ 1.695e+10Hz 0.846874 -0.458297
+ 1.7025e+10Hz 0.843789 -0.463482
+ 1.71e+10Hz 0.840664 -0.468641
+ 1.7175e+10Hz 0.837499 -0.473774
+ 1.725e+10Hz 0.834296 -0.478881
+ 1.7325e+10Hz 0.831054 -0.48396
+ 1.74e+10Hz 0.827776 -0.489012
+ 1.7475e+10Hz 0.824463 -0.494035
+ 1.755e+10Hz 0.821115 -0.499029
+ 1.7625e+10Hz 0.817734 -0.503995
+ 1.77e+10Hz 0.814321 -0.508933
+ 1.7775e+10Hz 0.810876 -0.513842
+ 1.785e+10Hz 0.807402 -0.518724
+ 1.7925e+10Hz 0.803899 -0.523579
+ 1.8e+10Hz 0.800367 -0.528408
+ 1.8075e+10Hz 0.796808 -0.533211
+ 1.815e+10Hz 0.793222 -0.53799
+ 1.8225e+10Hz 0.789609 -0.542746
+ 1.83e+10Hz 0.785968 -0.54748
+ 1.8375e+10Hz 0.782301 -0.552192
+ 1.845e+10Hz 0.778607 -0.556884
+ 1.8525e+10Hz 0.774885 -0.561557
+ 1.86e+10Hz 0.771135 -0.566212
+ 1.8675e+10Hz 0.767356 -0.570849
+ 1.875e+10Hz 0.763548 -0.575469
+ 1.8825e+10Hz 0.759708 -0.580072
+ 1.89e+10Hz 0.755836 -0.584659
+ 1.8975e+10Hz 0.751931 -0.58923
+ 1.905e+10Hz 0.747992 -0.593785
+ 1.9125e+10Hz 0.744018 -0.598324
+ 1.92e+10Hz 0.740007 -0.602845
+ 1.9275e+10Hz 0.735958 -0.607349
+ 1.935e+10Hz 0.731871 -0.611835
+ 1.9425e+10Hz 0.727744 -0.616301
+ 1.95e+10Hz 0.723577 -0.620747
+ 1.9575e+10Hz 0.719369 -0.625171
+ 1.965e+10Hz 0.71512 -0.629572
+ 1.9725e+10Hz 0.710829 -0.633949
+ 1.98e+10Hz 0.706497 -0.6383
+ 1.9875e+10Hz 0.702124 -0.642624
+ 1.995e+10Hz 0.69771 -0.646919
+ 2.0025e+10Hz 0.693256 -0.651185
+ 2.01e+10Hz 0.688762 -0.655421
+ 2.0175e+10Hz 0.684229 -0.659624
+ 2.025e+10Hz 0.679658 -0.663794
+ 2.0325e+10Hz 0.675051 -0.667931
+ 2.04e+10Hz 0.670408 -0.672033
+ 2.0475e+10Hz 0.665731 -0.676101
+ 2.055e+10Hz 0.661021 -0.680135
+ 2.0625e+10Hz 0.656279 -0.684133
+ 2.07e+10Hz 0.651507 -0.688097
+ 2.0775e+10Hz 0.646705 -0.692027
+ 2.085e+10Hz 0.641875 -0.695923
+ 2.0925e+10Hz 0.637017 -0.699786
+ 2.1e+10Hz 0.632132 -0.703617
+ 2.1075e+10Hz 0.627221 -0.707417
+ 2.115e+10Hz 0.622284 -0.711187
+ 2.1225e+10Hz 0.617321 -0.714927
+ 2.13e+10Hz 0.612333 -0.71864
+ 2.1375e+10Hz 0.607318 -0.722325
+ 2.145e+10Hz 0.602277 -0.725984
+ 2.1525e+10Hz 0.597208 -0.729618
+ 2.16e+10Hz 0.592112 -0.733228
+ 2.1675e+10Hz 0.586986 -0.736814
+ 2.175e+10Hz 0.581831 -0.740376
+ 2.1825e+10Hz 0.576643 -0.743915
+ 2.19e+10Hz 0.571424 -0.747431
+ 2.1975e+10Hz 0.56617 -0.750924
+ 2.205e+10Hz 0.56088 -0.754393
+ 2.2125e+10Hz 0.555554 -0.757837
+ 2.22e+10Hz 0.55019 -0.761257
+ 2.2275e+10Hz 0.544787 -0.76465
+ 2.235e+10Hz 0.539344 -0.768015
+ 2.2425e+10Hz 0.53386 -0.771351
+ 2.25e+10Hz 0.528334 -0.774656
+ 2.2575e+10Hz 0.522766 -0.777929
+ 2.265e+10Hz 0.517155 -0.781168
+ 2.2725e+10Hz 0.511503 -0.784371
+ 2.28e+10Hz 0.505808 -0.787536
+ 2.2875e+10Hz 0.500072 -0.790662
+ 2.295e+10Hz 0.494295 -0.793746
+ 2.3025e+10Hz 0.488478 -0.796787
+ 2.31e+10Hz 0.482622 -0.799784
+ 2.3175e+10Hz 0.476729 -0.802735
+ 2.325e+10Hz 0.4708 -0.805639
+ 2.3325e+10Hz 0.464838 -0.808496
+ 2.34e+10Hz 0.458842 -0.811304
+ 2.3475e+10Hz 0.452816 -0.814064
+ 2.355e+10Hz 0.446761 -0.816774
+ 2.3625e+10Hz 0.440679 -0.819437
+ 2.37e+10Hz 0.434571 -0.82205
+ 2.3775e+10Hz 0.428439 -0.824617
+ 2.385e+10Hz 0.422284 -0.827136
+ 2.3925e+10Hz 0.416107 -0.82961
+ 2.4e+10Hz 0.40991 -0.83204
+ 2.4075e+10Hz 0.403693 -0.834426
+ 2.415e+10Hz 0.397455 -0.83677
+ 2.4225e+10Hz 0.391198 -0.839074
+ 2.43e+10Hz 0.384922 -0.84134
+ 2.4375e+10Hz 0.378625 -0.843567
+ 2.445e+10Hz 0.372307 -0.845758
+ 2.4525e+10Hz 0.365966 -0.847914
+ 2.46e+10Hz 0.359603 -0.850035
+ 2.4675e+10Hz 0.353215 -0.852122
+ 2.475e+10Hz 0.346801 -0.854176
+ 2.4825e+10Hz 0.340358 -0.856197
+ 2.49e+10Hz 0.333886 -0.858184
+ 2.4975e+10Hz 0.327382 -0.860137
+ 2.505e+10Hz 0.320845 -0.862055
+ 2.5125e+10Hz 0.314273 -0.863936
+ 2.52e+10Hz 0.307665 -0.86578
+ 2.5275e+10Hz 0.301018 -0.867585
+ 2.535e+10Hz 0.294333 -0.869347
+ 2.5425e+10Hz 0.287607 -0.871066
+ 2.55e+10Hz 0.280841 -0.872739
+ 2.5575e+10Hz 0.274034 -0.874362
+ 2.565e+10Hz 0.267187 -0.875934
+ 2.5725e+10Hz 0.2603 -0.877452
+ 2.58e+10Hz 0.253373 -0.878912
+ 2.5875e+10Hz 0.246409 -0.880313
+ 2.595e+10Hz 0.239409 -0.881652
+ 2.6025e+10Hz 0.232374 -0.882927
+ 2.61e+10Hz 0.225307 -0.884135
+ 2.6175e+10Hz 0.21821 -0.885275
+ 2.625e+10Hz 0.211087 -0.886347
+ 2.6325e+10Hz 0.203939 -0.887348
+ 2.64e+10Hz 0.196771 -0.888279
+ 2.6475e+10Hz 0.189585 -0.88914
+ 2.655e+10Hz 0.182383 -0.88993
+ 2.6625e+10Hz 0.175169 -0.89065
+ 2.67e+10Hz 0.167945 -0.891302
+ 2.6775e+10Hz 0.160714 -0.891888
+ 2.685e+10Hz 0.153477 -0.892408
+ 2.6925e+10Hz 0.146237 -0.892865
+ 2.7e+10Hz 0.138994 -0.893262
+ 2.7075e+10Hz 0.13175 -0.893601
+ 2.715e+10Hz 0.124505 -0.893885
+ 2.7225e+10Hz 0.11726 -0.894115
+ 2.73e+10Hz 0.110012 -0.894295
+ 2.7375e+10Hz 0.102762 -0.894427
+ 2.745e+10Hz 0.0955073 -0.894513
+ 2.7525e+10Hz 0.0882469 -0.894556
+ 2.76e+10Hz 0.0809783 -0.894555
+ 2.7675e+10Hz 0.073699 -0.894513
+ 2.775e+10Hz 0.0664062 -0.894429
+ 2.7825e+10Hz 0.0590969 -0.894305
+ 2.79e+10Hz 0.0517682 -0.894138
+ 2.7975e+10Hz 0.0444171 -0.893929
+ 2.805e+10Hz 0.0370408 -0.893676
+ 2.8125e+10Hz 0.0296366 -0.893375
+ 2.82e+10Hz 0.0222022 -0.893025
+ 2.8275e+10Hz 0.0147356 -0.892623
+ 2.835e+10Hz 0.00723522 -0.892164
+ 2.8425e+10Hz -0.000299822 -0.891644
+ 2.85e+10Hz -0.00786994 -0.89106
+ 2.8575e+10Hz -0.0154749 -0.890407
+ 2.865e+10Hz -0.0231137 -0.88968
+ 2.8725e+10Hz -0.0307848 -0.888875
+ 2.88e+10Hz -0.038486 -0.887988
+ 2.8875e+10Hz -0.0462141 -0.887014
+ 2.895e+10Hz -0.0539658 -0.88595
+ 2.9025e+10Hz -0.0617367 -0.884792
+ 2.91e+10Hz -0.0695223 -0.883538
+ 2.9175e+10Hz -0.0773174 -0.882186
+ 2.925e+10Hz -0.0851168 -0.880735
+ 2.9325e+10Hz -0.0929147 -0.879183
+ 2.94e+10Hz -0.100706 -0.877532
+ 2.9475e+10Hz -0.108484 -0.875781
+ 2.955e+10Hz -0.116244 -0.873934
+ 2.9625e+10Hz -0.123981 -0.871993
+ 2.97e+10Hz -0.13169 -0.869961
+ 2.9775e+10Hz -0.139367 -0.867842
+ 2.985e+10Hz -0.147008 -0.865641
+ 2.9925e+10Hz -0.154612 -0.863363
+ 3e+10Hz -0.162175 -0.861013
+ ]

.ENDS

.SUBCKT IHP_PDK_basic_components_cap_cmim  gnd P1 P2  l=7.0u w=7.0u
X1 P1 P2 cap_cmim l={l} w={w}
.ENDS

.SUBCKT IHP_PDK_basic_components_rppd  gnd P1 P2 w=1.0e-6 l=0.5e-6 m=1
X1 P1 P2 rppd w={w} l={l} m={m}
.ENDS

.SUBCKT Sub_SPfile_L1 1 2
R1N 1 10 -50
R1P 10 11 100

A11 %vd(10 2) %vd(11, 2) xfer1
.model xfer1 xfer R_I=true table=[
+ 0Hz -0.894201 0
+ 7.5e+07Hz -0.892952 0.048473
+ 1.5e+08Hz -0.889213 0.0967726
+ 2.25e+08Hz -0.883006 0.144727
+ 3e+08Hz -0.874368 0.192166
+ 3.75e+08Hz -0.86335 0.238926
+ 4.5e+08Hz -0.850016 0.284846
+ 5.25e+08Hz -0.834444 0.329775
+ 6e+08Hz -0.816724 0.373567
+ 6.75e+08Hz -0.796957 0.416086
+ 7.5e+08Hz -0.775257 0.457209
+ 8.25e+08Hz -0.751744 0.49682
+ 9e+08Hz -0.726548 0.534818
+ 9.75e+08Hz -0.699806 0.571113
+ 1.05e+09Hz -0.67166 0.605629
+ 1.125e+09Hz -0.642256 0.638304
+ 1.2e+09Hz -0.611745 0.669089
+ 1.275e+09Hz -0.580276 0.69795
+ 1.35e+09Hz -0.548 0.724866
+ 1.425e+09Hz -0.515065 0.749831
+ 1.5e+09Hz -0.481618 0.772851
+ 1.575e+09Hz -0.447799 0.793944
+ 1.65e+09Hz -0.413745 0.813144
+ 1.725e+09Hz -0.379584 0.830491
+ 1.8e+09Hz -0.345436 0.846038
+ 1.875e+09Hz -0.311415 0.859847
+ 1.95e+09Hz -0.277622 0.871986
+ 2.025e+09Hz -0.244151 0.882531
+ 2.1e+09Hz -0.211083 0.891563
+ 2.175e+09Hz -0.17849 0.899165
+ 2.25e+09Hz -0.146433 0.905425
+ 2.325e+09Hz -0.114962 0.910431
+ 2.4e+09Hz -0.0841168 0.91427
+ 2.475e+09Hz -0.0539279 0.917028
+ 2.55e+09Hz -0.0244165 0.91879
+ 2.625e+09Hz 0.0044046 0.919636
+ 2.7e+09Hz 0.0325301 0.919642
+ 2.775e+09Hz 0.0599613 0.918882
+ 2.85e+09Hz 0.0867053 0.91742
+ 2.925e+09Hz 0.112774 0.915319
+ 3e+09Hz 0.138182 0.912634
+ 3.075e+09Hz 0.162949 0.909413
+ 3.15e+09Hz 0.187094 0.905701
+ 3.225e+09Hz 0.210638 0.901535
+ 3.3e+09Hz 0.233603 0.89695
+ 3.375e+09Hz 0.25601 0.891973
+ 3.45e+09Hz 0.277879 0.886629
+ 3.525e+09Hz 0.299229 0.880937
+ 3.6e+09Hz 0.320076 0.874915
+ 3.675e+09Hz 0.340436 0.868577
+ 3.75e+09Hz 0.360322 0.861936
+ 3.825e+09Hz 0.379743 0.855003
+ 3.9e+09Hz 0.39871 0.847787
+ 3.975e+09Hz 0.417228 0.840298
+ 4.05e+09Hz 0.435302 0.832546
+ 4.125e+09Hz 0.452935 0.824539
+ 4.2e+09Hz 0.47013 0.816288
+ 4.275e+09Hz 0.486886 0.807804
+ 4.35e+09Hz 0.503205 0.799099
+ 4.425e+09Hz 0.519086 0.790184
+ 4.5e+09Hz 0.534529 0.781075
+ 4.575e+09Hz 0.549533 0.771786
+ 4.65e+09Hz 0.564101 0.762332
+ 4.725e+09Hz 0.578232 0.75273
+ 4.8e+09Hz 0.591929 0.742996
+ 4.875e+09Hz 0.605196 0.73315
+ 4.95e+09Hz 0.618038 0.723207
+ 5.025e+09Hz 0.63046 0.713186
+ 5.1e+09Hz 0.64247 0.703104
+ 5.175e+09Hz 0.654076 0.692978
+ 5.25e+09Hz 0.66529 0.682825
+ 5.325e+09Hz 0.676122 0.672658
+ 5.4e+09Hz 0.686585 0.662494
+ 5.475e+09Hz 0.696692 0.652343
+ 5.55e+09Hz 0.706456 0.642219
+ 5.625e+09Hz 0.715894 0.63213
+ 5.7e+09Hz 0.72502 0.622086
+ 5.775e+09Hz 0.733849 0.612092
+ 5.85e+09Hz 0.742396 0.602156
+ 5.925e+09Hz 0.750677 0.592279
+ 6e+09Hz 0.758705 0.582465
+ 6.075e+09Hz 0.766494 0.572715
+ 6.15e+09Hz 0.774059 0.563028
+ 6.225e+09Hz 0.78141 0.553403
+ 6.3e+09Hz 0.788559 0.543838
+ 6.375e+09Hz 0.795516 0.534328
+ 6.45e+09Hz 0.802289 0.524872
+ 6.525e+09Hz 0.808888 0.515464
+ 6.6e+09Hz 0.815317 0.506101
+ 6.675e+09Hz 0.821584 0.496778
+ 6.75e+09Hz 0.827691 0.48749
+ 6.825e+09Hz 0.833642 0.478234
+ 6.9e+09Hz 0.83944 0.469006
+ 6.975e+09Hz 0.845086 0.459802
+ 7.05e+09Hz 0.850581 0.45062
+ 7.125e+09Hz 0.855925 0.441458
+ 7.2e+09Hz 0.861119 0.432314
+ 7.275e+09Hz 0.866161 0.423188
+ 7.35e+09Hz 0.871052 0.41408
+ 7.425e+09Hz 0.87579 0.404991
+ 7.5e+09Hz 0.880376 0.395921
+ 7.575e+09Hz 0.884808 0.386873
+ 7.65e+09Hz 0.889087 0.37785
+ 7.725e+09Hz 0.893214 0.368854
+ 7.8e+09Hz 0.897188 0.359888
+ 7.875e+09Hz 0.901012 0.350957
+ 7.95e+09Hz 0.904686 0.342064
+ 8.025e+09Hz 0.908214 0.333212
+ 8.1e+09Hz 0.911598 0.324405
+ 8.175e+09Hz 0.914842 0.315647
+ 8.25e+09Hz 0.917949 0.306942
+ 8.325e+09Hz 0.920925 0.298291
+ 8.4e+09Hz 0.923772 0.289699
+ 8.475e+09Hz 0.926497 0.281167
+ 8.55e+09Hz 0.929105 0.272696
+ 8.625e+09Hz 0.931601 0.264288
+ 8.7e+09Hz 0.93399 0.255944
+ 8.775e+09Hz 0.936278 0.247664
+ 8.85e+09Hz 0.93847 0.239447
+ 8.925e+09Hz 0.940571 0.231292
+ 9e+09Hz 0.942586 0.223198
+ 9.075e+09Hz 0.94452 0.215163
+ 9.15e+09Hz 0.946376 0.207185
+ 9.225e+09Hz 0.948159 0.199261
+ 9.3e+09Hz 0.949872 0.191389
+ 9.375e+09Hz 0.951517 0.183565
+ 9.45e+09Hz 0.953097 0.175786
+ 9.525e+09Hz 0.954614 0.16805
+ 9.6e+09Hz 0.956068 0.160353
+ 9.675e+09Hz 0.957461 0.152692
+ 9.75e+09Hz 0.958794 0.145064
+ 9.825e+09Hz 0.960065 0.137467
+ 9.9e+09Hz 0.961275 0.129899
+ 9.975e+09Hz 0.962423 0.122358
+ 1.005e+10Hz 0.963508 0.114842
+ 1.0125e+10Hz 0.96453 0.107349
+ 1.02e+10Hz 0.965486 0.0998795
+ 1.0275e+10Hz 0.966377 0.0924326
+ 1.035e+10Hz 0.967199 0.0850081
+ 1.0425e+10Hz 0.967954 0.0776063
+ 1.05e+10Hz 0.968639 0.0702279
+ 1.0575e+10Hz 0.969253 0.0628737
+ 1.065e+10Hz 0.969797 0.0555449
+ 1.0725e+10Hz 0.97027 0.0482429
+ 1.08e+10Hz 0.970671 0.0409692
+ 1.0875e+10Hz 0.971002 0.0337254
+ 1.095e+10Hz 0.971261 0.0265133
+ 1.1025e+10Hz 0.971452 0.0193345
+ 1.11e+10Hz 0.971574 0.0121907
+ 1.1175e+10Hz 0.971628 0.00508336
+ 1.125e+10Hz 0.971618 -0.00198605
+ 1.1325e+10Hz 0.971544 -0.00901636
+ 1.14e+10Hz 0.971409 -0.0160066
+ 1.1475e+10Hz 0.971215 -0.022956
+ 1.155e+10Hz 0.970964 -0.0298641
+ 1.1625e+10Hz 0.970659 -0.0367307
+ 1.17e+10Hz 0.970302 -0.0435559
+ 1.1775e+10Hz 0.969896 -0.0503403
+ 1.185e+10Hz 0.969443 -0.0570843
+ 1.1925e+10Hz 0.968945 -0.063789
+ 1.2e+10Hz 0.968404 -0.0704555
+ 1.2075e+10Hz 0.967823 -0.0770853
+ 1.215e+10Hz 0.967202 -0.0836799
+ 1.2225e+10Hz 0.966543 -0.090241
+ 1.23e+10Hz 0.965848 -0.0967705
+ 1.2375e+10Hz 0.965116 -0.10327
+ 1.245e+10Hz 0.96435 -0.109742
+ 1.2525e+10Hz 0.963548 -0.116188
+ 1.26e+10Hz 0.962711 -0.122609
+ 1.2675e+10Hz 0.961839 -0.129009
+ 1.275e+10Hz 0.960931 -0.135387
+ 1.2825e+10Hz 0.959987 -0.141745
+ 1.29e+10Hz 0.959006 -0.148085
+ 1.2975e+10Hz 0.957986 -0.154408
+ 1.305e+10Hz 0.956928 -0.160714
+ 1.3125e+10Hz 0.955828 -0.167004
+ 1.32e+10Hz 0.954687 -0.173278
+ 1.3275e+10Hz 0.953504 -0.179536
+ 1.335e+10Hz 0.952276 -0.185778
+ 1.3425e+10Hz 0.951004 -0.192003
+ 1.35e+10Hz 0.949686 -0.198211
+ 1.3575e+10Hz 0.948321 -0.204401
+ 1.365e+10Hz 0.94691 -0.210572
+ 1.3725e+10Hz 0.945451 -0.216722
+ 1.38e+10Hz 0.943944 -0.222851
+ 1.3875e+10Hz 0.942389 -0.228957
+ 1.395e+10Hz 0.940788 -0.23504
+ 1.4025e+10Hz 0.939139 -0.241098
+ 1.41e+10Hz 0.937444 -0.247129
+ 1.4175e+10Hz 0.935704 -0.253133
+ 1.425e+10Hz 0.93392 -0.259109
+ 1.4325e+10Hz 0.932092 -0.265056
+ 1.44e+10Hz 0.930223 -0.270974
+ 1.4475e+10Hz 0.928313 -0.276861
+ 1.455e+10Hz 0.926364 -0.282718
+ 1.4625e+10Hz 0.924377 -0.288545
+ 1.47e+10Hz 0.922355 -0.294342
+ 1.4775e+10Hz 0.920297 -0.300109
+ 1.485e+10Hz 0.918206 -0.305847
+ 1.4925e+10Hz 0.916083 -0.311556
+ 1.5e+10Hz 0.91393 -0.317238
+ 1.5075e+10Hz 0.911746 -0.322893
+ 1.515e+10Hz 0.909532 -0.328523
+ 1.5225e+10Hz 0.907291 -0.334129
+ 1.53e+10Hz 0.905021 -0.339712
+ 1.5375e+10Hz 0.902722 -0.345273
+ 1.545e+10Hz 0.900396 -0.350814
+ 1.5525e+10Hz 0.898042 -0.356336
+ 1.56e+10Hz 0.895659 -0.361841
+ 1.5675e+10Hz 0.893247 -0.367328
+ 1.575e+10Hz 0.890805 -0.3728
+ 1.5825e+10Hz 0.888332 -0.378256
+ 1.59e+10Hz 0.885827 -0.383699
+ 1.5975e+10Hz 0.88329 -0.389127
+ 1.605e+10Hz 0.880718 -0.394541
+ 1.6125e+10Hz 0.878112 -0.399942
+ 1.62e+10Hz 0.87547 -0.405329
+ 1.6275e+10Hz 0.87279 -0.410702
+ 1.635e+10Hz 0.870072 -0.416061
+ 1.6425e+10Hz 0.867315 -0.421404
+ 1.65e+10Hz 0.864518 -0.426731
+ 1.6575e+10Hz 0.861681 -0.432041
+ 1.665e+10Hz 0.858802 -0.437333
+ 1.6725e+10Hz 0.855883 -0.442606
+ 1.68e+10Hz 0.852921 -0.447858
+ 1.6875e+10Hz 0.849918 -0.453089
+ 1.695e+10Hz 0.846874 -0.458297
+ 1.7025e+10Hz 0.843789 -0.463482
+ 1.71e+10Hz 0.840664 -0.468641
+ 1.7175e+10Hz 0.837499 -0.473774
+ 1.725e+10Hz 0.834296 -0.478881
+ 1.7325e+10Hz 0.831054 -0.48396
+ 1.74e+10Hz 0.827776 -0.489012
+ 1.7475e+10Hz 0.824463 -0.494035
+ 1.755e+10Hz 0.821115 -0.499029
+ 1.7625e+10Hz 0.817734 -0.503995
+ 1.77e+10Hz 0.814321 -0.508933
+ 1.7775e+10Hz 0.810876 -0.513842
+ 1.785e+10Hz 0.807402 -0.518724
+ 1.7925e+10Hz 0.803899 -0.523579
+ 1.8e+10Hz 0.800367 -0.528408
+ 1.8075e+10Hz 0.796808 -0.533211
+ 1.815e+10Hz 0.793222 -0.53799
+ 1.8225e+10Hz 0.789609 -0.542746
+ 1.83e+10Hz 0.785968 -0.54748
+ 1.8375e+10Hz 0.782301 -0.552192
+ 1.845e+10Hz 0.778607 -0.556884
+ 1.8525e+10Hz 0.774885 -0.561557
+ 1.86e+10Hz 0.771135 -0.566212
+ 1.8675e+10Hz 0.767356 -0.570849
+ 1.875e+10Hz 0.763548 -0.575469
+ 1.8825e+10Hz 0.759708 -0.580072
+ 1.89e+10Hz 0.755836 -0.584659
+ 1.8975e+10Hz 0.751931 -0.58923
+ 1.905e+10Hz 0.747992 -0.593785
+ 1.9125e+10Hz 0.744018 -0.598324
+ 1.92e+10Hz 0.740007 -0.602845
+ 1.9275e+10Hz 0.735958 -0.607349
+ 1.935e+10Hz 0.731871 -0.611835
+ 1.9425e+10Hz 0.727744 -0.616301
+ 1.95e+10Hz 0.723577 -0.620747
+ 1.9575e+10Hz 0.719369 -0.625171
+ 1.965e+10Hz 0.71512 -0.629572
+ 1.9725e+10Hz 0.710829 -0.633949
+ 1.98e+10Hz 0.706497 -0.6383
+ 1.9875e+10Hz 0.702124 -0.642624
+ 1.995e+10Hz 0.69771 -0.646919
+ 2.0025e+10Hz 0.693256 -0.651185
+ 2.01e+10Hz 0.688762 -0.655421
+ 2.0175e+10Hz 0.684229 -0.659624
+ 2.025e+10Hz 0.679658 -0.663794
+ 2.0325e+10Hz 0.675051 -0.667931
+ 2.04e+10Hz 0.670408 -0.672033
+ 2.0475e+10Hz 0.665731 -0.676101
+ 2.055e+10Hz 0.661021 -0.680135
+ 2.0625e+10Hz 0.656279 -0.684133
+ 2.07e+10Hz 0.651507 -0.688097
+ 2.0775e+10Hz 0.646705 -0.692027
+ 2.085e+10Hz 0.641875 -0.695923
+ 2.0925e+10Hz 0.637017 -0.699786
+ 2.1e+10Hz 0.632132 -0.703617
+ 2.1075e+10Hz 0.627221 -0.707417
+ 2.115e+10Hz 0.622284 -0.711187
+ 2.1225e+10Hz 0.617321 -0.714927
+ 2.13e+10Hz 0.612333 -0.71864
+ 2.1375e+10Hz 0.607318 -0.722325
+ 2.145e+10Hz 0.602277 -0.725984
+ 2.1525e+10Hz 0.597208 -0.729618
+ 2.16e+10Hz 0.592112 -0.733228
+ 2.1675e+10Hz 0.586986 -0.736814
+ 2.175e+10Hz 0.581831 -0.740376
+ 2.1825e+10Hz 0.576643 -0.743915
+ 2.19e+10Hz 0.571424 -0.747431
+ 2.1975e+10Hz 0.56617 -0.750924
+ 2.205e+10Hz 0.56088 -0.754393
+ 2.2125e+10Hz 0.555554 -0.757837
+ 2.22e+10Hz 0.55019 -0.761257
+ 2.2275e+10Hz 0.544787 -0.76465
+ 2.235e+10Hz 0.539344 -0.768015
+ 2.2425e+10Hz 0.53386 -0.771351
+ 2.25e+10Hz 0.528334 -0.774656
+ 2.2575e+10Hz 0.522766 -0.777929
+ 2.265e+10Hz 0.517155 -0.781168
+ 2.2725e+10Hz 0.511503 -0.784371
+ 2.28e+10Hz 0.505808 -0.787536
+ 2.2875e+10Hz 0.500072 -0.790662
+ 2.295e+10Hz 0.494295 -0.793746
+ 2.3025e+10Hz 0.488478 -0.796787
+ 2.31e+10Hz 0.482622 -0.799784
+ 2.3175e+10Hz 0.476729 -0.802735
+ 2.325e+10Hz 0.4708 -0.805639
+ 2.3325e+10Hz 0.464838 -0.808496
+ 2.34e+10Hz 0.458842 -0.811304
+ 2.3475e+10Hz 0.452816 -0.814064
+ 2.355e+10Hz 0.446761 -0.816774
+ 2.3625e+10Hz 0.440679 -0.819437
+ 2.37e+10Hz 0.434571 -0.82205
+ 2.3775e+10Hz 0.428439 -0.824617
+ 2.385e+10Hz 0.422284 -0.827136
+ 2.3925e+10Hz 0.416107 -0.82961
+ 2.4e+10Hz 0.40991 -0.83204
+ 2.4075e+10Hz 0.403693 -0.834426
+ 2.415e+10Hz 0.397455 -0.83677
+ 2.4225e+10Hz 0.391198 -0.839074
+ 2.43e+10Hz 0.384922 -0.84134
+ 2.4375e+10Hz 0.378625 -0.843567
+ 2.445e+10Hz 0.372307 -0.845758
+ 2.4525e+10Hz 0.365966 -0.847914
+ 2.46e+10Hz 0.359603 -0.850035
+ 2.4675e+10Hz 0.353215 -0.852122
+ 2.475e+10Hz 0.346801 -0.854176
+ 2.4825e+10Hz 0.340358 -0.856197
+ 2.49e+10Hz 0.333886 -0.858184
+ 2.4975e+10Hz 0.327382 -0.860137
+ 2.505e+10Hz 0.320845 -0.862055
+ 2.5125e+10Hz 0.314273 -0.863936
+ 2.52e+10Hz 0.307665 -0.86578
+ 2.5275e+10Hz 0.301018 -0.867585
+ 2.535e+10Hz 0.294333 -0.869347
+ 2.5425e+10Hz 0.287607 -0.871066
+ 2.55e+10Hz 0.280841 -0.872739
+ 2.5575e+10Hz 0.274034 -0.874362
+ 2.565e+10Hz 0.267187 -0.875934
+ 2.5725e+10Hz 0.2603 -0.877452
+ 2.58e+10Hz 0.253373 -0.878912
+ 2.5875e+10Hz 0.246409 -0.880313
+ 2.595e+10Hz 0.239409 -0.881652
+ 2.6025e+10Hz 0.232374 -0.882927
+ 2.61e+10Hz 0.225307 -0.884135
+ 2.6175e+10Hz 0.21821 -0.885275
+ 2.625e+10Hz 0.211087 -0.886347
+ 2.6325e+10Hz 0.203939 -0.887348
+ 2.64e+10Hz 0.196771 -0.888279
+ 2.6475e+10Hz 0.189585 -0.88914
+ 2.655e+10Hz 0.182383 -0.88993
+ 2.6625e+10Hz 0.175169 -0.89065
+ 2.67e+10Hz 0.167945 -0.891302
+ 2.6775e+10Hz 0.160714 -0.891888
+ 2.685e+10Hz 0.153477 -0.892408
+ 2.6925e+10Hz 0.146237 -0.892865
+ 2.7e+10Hz 0.138994 -0.893262
+ 2.7075e+10Hz 0.13175 -0.893601
+ 2.715e+10Hz 0.124505 -0.893885
+ 2.7225e+10Hz 0.11726 -0.894115
+ 2.73e+10Hz 0.110012 -0.894295
+ 2.7375e+10Hz 0.102762 -0.894427
+ 2.745e+10Hz 0.0955073 -0.894513
+ 2.7525e+10Hz 0.0882469 -0.894556
+ 2.76e+10Hz 0.0809783 -0.894555
+ 2.7675e+10Hz 0.073699 -0.894513
+ 2.775e+10Hz 0.0664062 -0.894429
+ 2.7825e+10Hz 0.0590969 -0.894305
+ 2.79e+10Hz 0.0517682 -0.894138
+ 2.7975e+10Hz 0.0444171 -0.893929
+ 2.805e+10Hz 0.0370408 -0.893676
+ 2.8125e+10Hz 0.0296366 -0.893375
+ 2.82e+10Hz 0.0222022 -0.893025
+ 2.8275e+10Hz 0.0147356 -0.892623
+ 2.835e+10Hz 0.00723522 -0.892164
+ 2.8425e+10Hz -0.000299822 -0.891644
+ 2.85e+10Hz -0.00786994 -0.89106
+ 2.8575e+10Hz -0.0154749 -0.890407
+ 2.865e+10Hz -0.0231137 -0.88968
+ 2.8725e+10Hz -0.0307848 -0.888875
+ 2.88e+10Hz -0.038486 -0.887988
+ 2.8875e+10Hz -0.0462141 -0.887014
+ 2.895e+10Hz -0.0539658 -0.88595
+ 2.9025e+10Hz -0.0617367 -0.884792
+ 2.91e+10Hz -0.0695223 -0.883538
+ 2.9175e+10Hz -0.0773174 -0.882186
+ 2.925e+10Hz -0.0851168 -0.880735
+ 2.9325e+10Hz -0.0929147 -0.879183
+ 2.94e+10Hz -0.100706 -0.877532
+ 2.9475e+10Hz -0.108484 -0.875781
+ 2.955e+10Hz -0.116244 -0.873934
+ 2.9625e+10Hz -0.123981 -0.871993
+ 2.97e+10Hz -0.13169 -0.869961
+ 2.9775e+10Hz -0.139367 -0.867842
+ 2.985e+10Hz -0.147008 -0.865641
+ 2.9925e+10Hz -0.154612 -0.863363
+ 3e+10Hz -0.162175 -0.861013
+ ]

.ENDS

.SUBCKT IHP_PDK_basic_components_rhigh  gnd P1 P2 w=1.0e-6 l=0.5e-6 m=1
X1 P1 P2 rhigh w={w} l={l} m={m}
.ENDS

.LIB cornerMOSlv.lib mos_tt
.LIB cornerCAP.lib cap_typ
.LIB cornerRES.lib res_wcs

.PARAM nmos_w = 106
.PARAM n_finger = 11
Xnmos2 0  _net0 Vdd _net1 0 IHP_PDK_nonlinear_components_sg13_lv_nmos w={NMOS_W*10E-6} l=0.130U ng={N_FINGER} m=1 as=0 ad=0 pd=0 ps=0 trise=0 z1=0.346E-6 z2=0.38E-6 wmin=0.15E-6 rfmode=0 pre_layout=1
C3 _net2 _net0  1
VPr1 _net1 _net3 DC 0
VP2 _net2 0 dc 0 ac 6.32456 SIN(0 6.32456 1MEG) portnum 2 z0 5000
XLs _net4 0 Sub_SPfile_Ls
XLL _net0 Vdd 0 Sub_SPfile_LL
Xcap_cmim1 0  Vdd _net0 IHP_PDK_basic_components_cap_cmim l=21.5U w=21.5U
Xrppd1 0  Vdd _net0 IHP_PDK_basic_components_rppd w=4.7U l=4.6U m=1
Xnmos1 0  _net3 _net5 _net4 0 IHP_PDK_nonlinear_components_sg13_lv_nmos w={NMOS_W*10E-6} l=0.130U ng={N_FINGER} m=1 as=0 ad=0 pd=0 ps=0 trise=0 z1=0.346E-6 z2=0.38E-6 wmin=0.15E-6 rfmode=0 pre_layout=1
vdd Vdd 0 DC 1.2
XL1 _net6 _net5 0 Sub_SPfile_L1
Xnmos3 0  _net7 _net7 0 gnd IHP_PDK_nonlinear_components_sg13_lv_nmos w=205U l=0.70U ng=1 m=1 as=0 ad=0 pd=0 ps=0 trise=0 z1=0.346E-6 z2=0.38E-6 wmin=0.15E-6 rfmode=0 pre_layout=1
C4 _net6 _net8  1
VP3 _net8 0 dc 0 ac 0.632456 SIN(0 0.632456 2.45G) portnum 1 z0 50
LB1 Vdd _net9  1
Xrhigh1 0  _net7 _net6 IHP_PDK_basic_components_rhigh w=1U l=2U m=1

Xrppd2 0  _net9 _net7 IHP_PDK_basic_components_rppd w=1U l=1.88U m=1

.control

SP LIN 501 500MEG 5G 1
let g = dB(s_2_1) + 10*log10(5000/50)
write spice4qucs.sp1.plot S_1_1 Y_1_1 Z_1_1 Cy_1_1 S_1_2 Y_1_2 Z_1_2 Cy_1_2 S_2_1 Y_2_1 Z_2_1 Cy_2_1 S_2_2 Y_2_2 Z_2_2 Cy_2_2 Rn NF SOpt NFmin g
destroy all
reset

exit
.endc
.END
